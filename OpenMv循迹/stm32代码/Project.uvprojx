# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\System\delay;.\System\sys;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src;.\Hardware\OLED;.\Hardware\MyTask;.\Hardware\Servos;.\Hardware\Led;.\Hardware\Vbatt;.\Hardware\Pwm;.\Hardware\Motor;.\Hardware\Encoder;.\Hardware\Pid;.\Hardware\MyTimer;.\Hardware\MyUsart;.\Net\device;.\Net\MQTT;.\Net\onenet;.\System\usart;.\Net\cJSON;.\Hardware\Voice
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/sys/: sys.c
    ./System/delay/: delay.c
    ./System/usart/: usart.c
  group Hardware
    ./Hardware/MyTask/: mytask.c
    ./Hardware/OLED/: OLED.c
    ./Hardware/Servos/: servos.c
    ./Hardware/Pwm/: pwm.c
    ./Hardware/Motor/: motor.c
    ./Hardware/Encoder/: encoder.c
    ./Hardware/Pid/: pid.c
    ./Hardware/MyTimer/: mytimer.c
    ./Net/cJSON/: cJSON.c
  group Net
    ./Net/device/: esp8266.c
    ./Net/MQTT/: MqttKit.c
    ./Net/onenet/: onenet.c
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
  group FreeRTOS-inc
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/inc/: FreeRTOS.h atomic.h croutine.h deprecated_definitions.h event_groups.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS-src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS-port
    ./FreeRTOS/port/: heap_4.c port.c
